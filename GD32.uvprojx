# Keil uVision project GD32.uvprojx, settings and files
target GateWay (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303_GateWay
  AfterMake: fromelf --bin  -o  .\tmp\output\charge.bin   .\tmp\output\GD32F303_GateWay.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__FPU_PRESENT
  c include: .\Library\Firmware\GD32F30x_standard_peripheral\Include;.\Library\Firmware\CMSIS;.\Library\Firmware\CMSIS\GD\GD32F30x\Include;.\Hardware;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\Hardware\Config\ADC;.\Hardware\Config\GPIO;.\Hardware\Config\RTC;.\Hardware\Config\SPI;.\Hardware\Config\SYSTEM;.\Hardware\Config\TIMER;.\Hardware\Config\USART;.\Hardware\Config\WATCHDOG;.\Hardware\APP\LED;.\Hardware\APP\RELAY;.\Hardware\Config\FIFO;.\Hardware\Config\SYS;.\Hardware\APP\CHARGE;.\Hardware\APP\METER;.\Hardware\APP\START;.\Hardware\APP\FLASH;.\Hardware\APP\ORDER;.\Hardware\APP\EC200S;.\Hardware\APP\MESSAGE;.\Hardware\APP\CHARGE;.\Hardware\Config\I2S;.\Hardware\APP\NFC;.\Hardware\APP\CHECK;.\JSON;.\Hardware\APP\VOICE;.\Hardware\APP\KEYBOARD
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./Hardware/: gd32f30x_it.c main.c systick.c FreeRTOSConfig.h
    ./: 实验说明.txt
  group FreeRTSO/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/porttable
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group CMSIS
    ./Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group StartUp
    ./Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group GD32F30x_Lib
    ./Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Config
    ./Hardware/Config/ADC/: adc.c
    ./Hardware/Config/GPIO/: gpio.c
    ./Hardware/Config/RTC/: rtc.c
    ./Hardware/Config/SPI/: spi.c
    ./Hardware/Config/SYSTEM/: system.c
    ./Hardware/Config/TIMER/: timer.c
    ./Hardware/Config/USART/: usart.c
    ./Hardware/Config/WATCHDOG/: watchdog.c
    ./Hardware/Config/SYS/: sys.c
    ./Hardware/Config/FIFO/: fifo.c
    ./Hardware/Config/I2S/: i2s.c
  group APP
    ./Hardware/APP/LED/: led.c
    ./Hardware/APP/RELAY/: relay_control.c
    ./Hardware/APP/CHARGE/: charge.c
    ./Hardware/APP/FLASH/: flash.c App_GD25xx.c
    ./Hardware/APP/METER/: meter.c
    ./Hardware/APP/START/: start.c
    ./Hardware/APP/ORDER/: order.c
    ./Hardware/APP/EC200S/: BswAbstr_Ec200s.c BswDrv_Ec200s.c BswSrv_Ec200s.c
    ./Hardware/APP/MESSAGE/: netmessage.c
    ./Hardware/APP/NFC/: fm175xx.c mcard.c
    ./Hardware/APP/CHECK/: Device_check.c
    ./Hardware/APP/VOICE/: App_Voice.c
    ./Hardware/APP/KEYBOARD/: App_CkbProto.c
  group JSON
    ./JSON/: cJSON.c
